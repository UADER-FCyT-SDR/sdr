options:
  parameters:
    author: Dr. Pedro E. Colla
    copyright: UADER
    description: Basic smoke test script
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: SDR Basic setup test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: sdrSmoke_multDivSelect_0
  id: sdrSmoke_multDivSelect
  parameters:
    selector: 'True'
  states: {}

connections:
- [analog_const_source_x_0, '0', sdrSmoke_multDivSelect_0, '1']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_1, '0']
- [analog_sig_source_x_0, '0', sdrSmoke_multDivSelect_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [sdrSmoke_multDivSelect_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
