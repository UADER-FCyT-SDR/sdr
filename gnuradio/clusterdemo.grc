options:
  parameters:
    generate_options: qt_gui
    id: clusterdemo
    output_language: python
    title: SDR-Custom Module Demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '2'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: customModule_multDivSelect_0
  id: customModule_multDivSelect
  parameters:
    selector: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', customModule_multDivSelect_0, '1']
- [analog_sig_source_x_0, '0', customModule_multDivSelect_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [customModule_multDivSelect_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
